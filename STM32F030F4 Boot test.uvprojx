# Keil uVision project STM32F030F4 Boot test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030F4 Boot test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x3fff
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Objects\STM32F030F4 Boot test.sct
  group Libs
    ./: main.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
